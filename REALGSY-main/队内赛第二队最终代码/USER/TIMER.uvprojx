# Keil uVision project TIMER.uvprojx, settings and files
target TIMER (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEAM2 +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\Devices\CONTROL;..\Devices\ENCODER;..\Devices\KEY;..\Devices\LED;..\Devices\MOTO;..\Devices\PS2;..\Devices\Servo;..\OBJ;..\STM32F10x_FWLib\inc;..\STM32F10x_FWLib\src;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\Task\DEBUG_DATASCOPE;..\Task\TIMER;.\DebugConfig;..\Devices;..\STM32F10x_FWLib;..\SYSTEM;..\Task;..\USER;..\Devices\RED;..\Devices\Servo;..\Devices\BEEP;..\Devices\eyes;..\Devices\follow
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group README
    ../: README.TXT
  group Basis
    ../Devices/ENCODER/: encoder.c
    ../Devices/LED/: led.c
    ../Devices/KEY/: key.c
    ../Devices/MOTO/: moto.c
    ../Devices/PS2/: PS2.c
    ../Devices/RED/: red.c
    ../Devices/Servo/: Servo.c
    ../Devices/BEEP/: beep.c
    ../Devices/eyes/: eyes.c
    ../Devices/follow/: follow.c
  group Task
    ../Task/DEBUG_DATASCOPE/: Debug_DataScope.C
    ../Task/TIMER/: timer.c
  group Apps
    ../Devices/CONTROL/: control.c
